SNOOP_DEVICE:ax3000 = "ax-espi-snoop"