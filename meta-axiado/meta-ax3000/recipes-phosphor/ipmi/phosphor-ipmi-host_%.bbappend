PACKAGECONFIG:append = " dynamic-sensors"

