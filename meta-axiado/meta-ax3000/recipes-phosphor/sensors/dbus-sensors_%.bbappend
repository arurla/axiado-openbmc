PACKAGECONFIG:remove = " \
    adcsensor \
    intelcpusensor \
    exitairtempsensor \
    intrusionsensor \
    ipmbsensor \
    mcutempsensor \
    psusensor \
    external \
    "


