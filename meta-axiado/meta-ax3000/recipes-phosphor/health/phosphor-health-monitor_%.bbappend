FILESEXTRAPATHS:prepend := "${THISDIR}/${PN}:"

SRC_URI += "file://0001-Make-health-monitor-compatible-with-sensor-list-comm.patch"
